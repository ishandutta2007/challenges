options:
  parameters:
    generate_options: qt_gui
    id: sampling_aliasing
    output_language: python
    title: Sampling and Aliasing
  states: {}

blocks:
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1,1,1
    label: Sample Rate
    label0: 8 kHz
    label1: 16 kHz
    label2: 32 kHz
    label3: 48 kHz
    num_opts: '4'
    option0: '8000'
    option1: '16000'
    option2: '32000'
    option3: '48000'
    orient: Qt.QHBoxLayout
    type: int
    value: '8000'
    widget: radio_buttons
  states: {}
- name: signal_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Signal Frequency
    orient: Qt.Horizontal
    start: '-10000'
    step: '1000'
    stop: '10000'
    value: '0'
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,2,1
    label: Waveform
    label0: Cosine
    label1: Square
    label2: Triangle
    num_opts: '3'
    option0: '102'
    option1: '103'
    option2: '104'
    type: int
    value: '102'
    widget: radio_buttons
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: signal_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: waveform
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,1,1,1
    legend: 'False'
    name: Spectrum
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: I
    name: Waveform
    size: '50'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
