/*

You have to write a program or a function in any language that outputs this pattern:

~|||||||||||||||||||||||||||||||||||||||||||||||||||||||||||~
|~|||||||||||||||||||||||||||||||||||||||||||||||||||||||||~|
||~|||||||||||||||||||||||||||||||||||||||||||||||||||||||~||
|||~|||||||||||||||||||||||||||||||||||||||||||||||||||||~|||
||||~|||||||||||||||||||||||||||||||||||||||||||||||||||~||||
|||||~|||||||||||||||||||||||||||||||||||||||||||||||||~|||||
||||||~|||||||||||||||||||||||||||||||||||||||||||||||~||||||
|||||||~|||||||||||||||||||||||||||||||||||||||||||||~|||||||
||||||||~|||||||||||||||||||||||||||||||||||||||||||~||||||||
|||||||||~|||||||||||||||||||||||||||||||||||||||||~|||||||||
||||||||||~|||||||||||||||||||~|||||||||||||||||||~||||||||||
|||||||||||~|||||||||||||||||~|~|||||||||||||||||~|||||||||||
||||||||||||~|||||||||||||||~|||~|||||||||||||||~||||||||||||
|||||||||||||~|||||||||||||~|||||~|||||||||||||~|||||||||||||
||||||||||||||~|||||||||||~|||||||~|||||||||||~||||||||||||||
|||||||||||||||~|||||||||~|||||||||~|||||||||~|||||||||||||||
||||||||||||||||~|||||||~|||||||||||~|||||||~||||||||||||||||
|||||||||||||||||~|||||~|||||||||||||~|||||~|||||||||||||||||
||||||||||||||||||~|||~|||||||||||||||~|||~||||||||||||||||||
|||||||||||||||||||~|~|||||||||||||||||~|~|||||||||||||||||||
The output is composed of 20 lines of 61 characters each.

Rules
Standard loopholes are forbidden
There may be a single trailing newline at the end of the output
There may not be any trailing whitespace on any line of the output
Without a trailing newline, the md5 checksum of the output is fde4e3b4606bf9f8c314131c93988e96.

With a trailing newline, the md5 checksum of the output is 1f0b43db4fec6594be202c8339024cb7.

This is code-golf, so the shortest code in bytes wins.

*/

#include <stdio.h>
#include <string.h>

#define nelem(x) (sizeof(x) / sizeof(x[0]))

void
logo(void)
{
	char p[20][61];
	int w, h;
	int i, j;

	h = nelem(p);
	w = nelem(p[0]);
	memset(p, '|', w * h);

	for (i = 0; i < h; i++) {
		p[i][i] = '~';
		p[i][w - i - 1] = '~';
	}

	for (i = 0; i < 9; i++) {
		p[11 + i][31 + i] = '~';
		p[11 + i][31 - i - 2] = '~';
	}
	p[10][30] = '~';

	for (i = 0; i < h; i++) {
		for (j = 0; j < w; j++)
			printf("%c", p[i][j]);
		printf("\n");
	}
}

int
main(void)
{
	logo();
	return 0;
}
